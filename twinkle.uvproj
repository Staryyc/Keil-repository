# Keil uVision project twinkle.uvproj, settings and files
target twinkle (ARM-ADS)
  device: AT89C52 Atmel
  cpu: IROM(0-0x1FFF) ICOD(0x0-0xFF) IRAM(0x0-0xFF) XRAM(0x0-0xFFFF) CPUTYPE("8051") CLOCK(12000000)
  output: twinkle +hex
  c flags: Optim=1 OneElfS=1 wLevel=2
  memory RVCT4: ROM 0x0 size 0x2000
  group Source
    ./: twinkle.c
