# Keil uVision project twinkle_Keil5.uvprojx, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) XRAM(0-0xFFFF) CLOCK(12000000)
  output: twinkle +hex
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: twinkle.c
